# Keil uVision project proj_template.uvprojx, settings and files
target PANCHIP_BLE_APP (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: proj_template +hex
  AfterMake: fromelf  --bin -o ./Out/@L.bin  ./Out/@L.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __CC_ARM
  c misc: --c99 --thumb -c --bss_threshold=0
  c include: ..\..\src\application\inc;..\..\src\application\dbg\api;..\..\src\platform\arch\inc;..\..\src\platform\build\reg;..\..\src\platform\driver\inc;..\..\src\prf\prf_ctl\inc;..\..\src\stack\hci;..\..\src\stack\inc;..\..\src\stack\gatt\attc;..\..\src\stack\gatt\attm;..\..\src\stack\gatt\atts;..\..\src\stack\gatt\gattc;..\..\src\stack\gatt\gattm;..\..\src\stack\hci;..\..\src\prf\profiles\anp\api;..\..\src\prf\profiles\bas\api;..\..\src\prf\profiles\blp\api;..\..\src\prf\profiles\cpp\api;..\..\src\prf\profiles\dis\api;..\..\src\prf\profiles\find\api;..\..\src\prf\profiles\glp\api;..\..\src\prf\profiles\hogp\api;..\..\src\prf\profiles\hrp\api;..\..\src\prf\profiles\htp\api;..\..\src\prf\profiles\lan\api;..\..\src\prf\profiles\pasp\api;..\..\src\prf\profiles\prox\api;..\..\src\prf\profiles\rscp\api;..\..\src\prf\profiles\tip\api;..\..\src\stack\softdevice;..\..\src\application\ota;.\proj_template\proj_template;.\proj_template\proj_template\proj_template_server;..\proj_template;.\proj_template;..\..\src\application\flash_manager\inc;.\proj_template\mcu_hal;.\proj_template\my_app
  library: MicroLIB
  memory RVCT4: ROM 0x16800 size 0x12c00
  memory RVCT9: RAM 0x20002700 size 0x1900
  link misc: --datacompressor=off --info=inline --entry Reset_Handler
  group Startup Files
    ../../src/platform/arch/boot/: system_PN102Series.c startup_PN102Series.s
  group arch
    ./proj_template/: peripherals.c arch_main.c
    ../../src/platform/arch/src/: printf.c
  group app_panip
    ../../src/application/src/: app.c app_proj_event.c app_task.c app_sec.c app_temp_adc.c
  group host_gatt
    ../../src/stack/gatt/attc/: attc.c
    ../../src/stack/gatt/attm/: attm.c attm_db.c
    ../../src/stack/gatt/atts/: atts.c
    ../../src/stack/gatt/gattc/: gattc.c gattc_task.c
    ../../src/stack/gatt/gattm/: gattm.c gattm_task.c
  group host_hci
    ../../src/stack/hci/: hci.c hci_msg.c hci_tl.c hci_fc.c hci_cmd.c hci_uart.c hci_uart_task.c whitening.c
  group host_prf
    ../../src/prf/prf_ctl/src/: prf.c prf_utils.c
  group driver
    ../../src/platform/driver/src/: adc.c clk.c dma.c fmc.c gpio.c i2c.c pwm.c spi.c sys.c timer.c uart.c wdt.c wwdt.c
  group app_proj_template
    ./proj_template/: proj_template.c
    ./proj_template/proj_template/: app_proj_template.c
    ./proj_template/proj_template/proj_template_server/: proj_template_server_task.c proj_template_server.c
  group app_ota
    ../../src/application/ota/: app_ota.c ota_server.c ota_server_task.c
  group flash_manager
    ../../src/application/flash_manager/src/: app_flash.c bearer_event.c flash_manager.c flash_manager_defrag.c flash_manager_internal.c hal_flash_driver.c mesh_flash.c msqueue.c packet_buffer.c queue.c
  group mcu_hal
    ./proj_template/mcu_hal/: mcu_hal.c
  group my_app
    ./proj_template/my_app/: temperature.c led_app.c key_app.c rev_app.c
target PANCHIP_BLE_STACK (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: as above
  output: stack_1.0.0.hex +hex
  AfterMake: fromelf  --bin -o ./Out/@L.bin  ./Out/@L.axf
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __CC_ARM
  c misc: --c99 --thumb -c --bss_threshold=0
  c include: ..\..\src\application\inc;..\..\src\application\dbg\api;..\..\src\platform\arch\inc;..\..\src\platform\build\reg;..\..\src\platform\driver\inc;..\..\src\prf\prf_ctl\inc;..\..\src\stack\hci;..\..\src\stack\inc;..\..\src\stack\gatt\attc;..\..\src\stack\gatt\attm;..\..\src\stack\gatt\atts;..\..\src\stack\gatt\gattc;..\..\src\stack\gatt\gattm;..\..\src\stack\hci;..\..\src\prf\profiles\anp\api;..\..\src\prf\profiles\bas\api;..\..\src\prf\profiles\blp\api;..\..\src\prf\profiles\cpp\api;..\..\src\prf\profiles\dis\api;..\..\src\prf\profiles\find\api;..\..\src\prf\profiles\glp\api;..\..\src\prf\profiles\hogp\api;..\..\src\prf\profiles\hrp\api;..\..\src\prf\profiles\htp\api;..\..\src\prf\profiles\lan\api;..\..\src\prf\profiles\pasp\api;..\..\src\prf\profiles\prox\api;..\..\src\prf\profiles\rscp\api;..\..\src\prf\profiles\tip\api;.\proj_template\ota;.\proj_template\proj_template;.\proj_template\proj_template\proj_template_server;..\proj_template;.\proj_template
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --datacompressor=off --info=inline --entry Reset_Handler
software components: CMSIS:CORE 5.4.0
